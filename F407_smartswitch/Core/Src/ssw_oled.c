/* SSD1306 128x32 renderer (see ssw_oled.h). Identical copy in both projects. */
#include "ssw_oled.h"
#include <string.h>

/* Classic 5x7 font, ASCII 32..126, one byte per column, bit 0 = top. */
static const uint8_t font5x7[95][5] = {
  {0x00,0x00,0x00,0x00,0x00},{0x00,0x00,0x5F,0x00,0x00},{0x00,0x07,0x00,0x07,0x00},{0x14,0x7F,0x14,0x7F,0x14},
  {0x24,0x2A,0x7F,0x2A,0x12},{0x23,0x13,0x08,0x64,0x62},{0x36,0x49,0x55,0x22,0x50},{0x00,0x05,0x03,0x00,0x00},
  {0x00,0x1C,0x22,0x41,0x00},{0x00,0x41,0x22,0x1C,0x00},{0x14,0x08,0x3E,0x08,0x14},{0x08,0x08,0x3E,0x08,0x08},
  {0x00,0x50,0x30,0x00,0x00},{0x08,0x08,0x08,0x08,0x08},{0x00,0x60,0x60,0x00,0x00},{0x20,0x10,0x08,0x04,0x02},
  {0x3E,0x51,0x49,0x45,0x3E},{0x00,0x42,0x7F,0x40,0x00},{0x42,0x61,0x51,0x49,0x46},{0x21,0x41,0x45,0x4B,0x31},
  {0x18,0x14,0x12,0x7F,0x10},{0x27,0x45,0x45,0x45,0x39},{0x3C,0x4A,0x49,0x49,0x30},{0x01,0x71,0x09,0x05,0x03},
  {0x36,0x49,0x49,0x49,0x36},{0x06,0x49,0x49,0x29,0x1E},{0x00,0x36,0x36,0x00,0x00},{0x00,0x56,0x36,0x00,0x00},
  {0x08,0x14,0x22,0x41,0x00},{0x14,0x14,0x14,0x14,0x14},{0x00,0x41,0x22,0x14,0x08},{0x02,0x01,0x51,0x09,0x06},
  {0x32,0x49,0x79,0x41,0x3E},{0x7E,0x11,0x11,0x11,0x7E},{0x7F,0x49,0x49,0x49,0x36},{0x3E,0x41,0x41,0x41,0x22},
  {0x7F,0x41,0x41,0x22,0x1C},{0x7F,0x49,0x49,0x49,0x41},{0x7F,0x09,0x09,0x09,0x01},{0x3E,0x41,0x49,0x49,0x7A},
  {0x7F,0x08,0x08,0x08,0x7F},{0x00,0x41,0x7F,0x41,0x00},{0x20,0x40,0x41,0x3F,0x01},{0x7F,0x08,0x14,0x22,0x41},
  {0x7F,0x40,0x40,0x40,0x40},{0x7F,0x02,0x0C,0x02,0x7F},{0x7F,0x04,0x08,0x10,0x7F},{0x3E,0x41,0x41,0x41,0x3E},
  {0x7F,0x09,0x09,0x09,0x06},{0x3E,0x41,0x51,0x21,0x5E},{0x7F,0x09,0x19,0x29,0x46},{0x46,0x49,0x49,0x49,0x31},
  {0x01,0x01,0x7F,0x01,0x01},{0x3F,0x40,0x40,0x40,0x3F},{0x1F,0x20,0x40,0x20,0x1F},{0x3F,0x40,0x38,0x40,0x3F},
  {0x63,0x14,0x08,0x14,0x63},{0x07,0x08,0x70,0x08,0x07},{0x61,0x51,0x49,0x45,0x43},{0x00,0x7F,0x41,0x41,0x00},
  {0x02,0x04,0x08,0x10,0x20},{0x00,0x41,0x41,0x7F,0x00},{0x04,0x02,0x01,0x02,0x04},{0x40,0x40,0x40,0x40,0x40},
  {0x00,0x01,0x02,0x04,0x00},{0x20,0x54,0x54,0x54,0x78},{0x7F,0x48,0x44,0x44,0x38},{0x38,0x44,0x44,0x44,0x20},
  {0x38,0x44,0x44,0x48,0x7F},{0x38,0x54,0x54,0x54,0x18},{0x08,0x7E,0x09,0x01,0x02},{0x0C,0x52,0x52,0x52,0x3E},
  {0x7F,0x08,0x04,0x04,0x78},{0x00,0x44,0x7D,0x40,0x00},{0x20,0x40,0x44,0x3D,0x00},{0x7F,0x10,0x28,0x44,0x00},
  {0x00,0x41,0x7F,0x40,0x00},{0x7C,0x04,0x18,0x04,0x78},{0x7C,0x08,0x04,0x04,0x78},{0x38,0x44,0x44,0x44,0x38},
  {0x7C,0x14,0x14,0x14,0x08},{0x08,0x14,0x14,0x18,0x7C},{0x7C,0x08,0x04,0x04,0x08},{0x48,0x54,0x54,0x54,0x20},
  {0x04,0x3F,0x44,0x40,0x20},{0x3C,0x40,0x40,0x20,0x7C},{0x1C,0x20,0x40,0x20,0x1C},{0x3C,0x40,0x30,0x40,0x3C},
  {0x44,0x28,0x10,0x28,0x44},{0x0C,0x50,0x50,0x50,0x3C},{0x44,0x64,0x54,0x4C,0x44},{0x00,0x08,0x36,0x41,0x00},
  {0x00,0x00,0x7F,0x00,0x00},{0x00,0x41,0x36,0x08,0x00},{0x08,0x04,0x08,0x10,0x08},
};

static const uint8_t *glyph(char c)
{
  unsigned char u = (unsigned char)c;
  if (u < 32U || u > 126U) u = '?';
  return font5x7[u - 32U];
}

/* ---- panel ---------------------------------------------------------------- */
bool SswOled_Init(SswOledWrite w, uint8_t contrast)
{
  const uint8_t seq[] = {
    0xAE,              /* display off */
    0xD5, 0x80,        /* clock divide */
    0xA8, 0x1F,        /* multiplex 32 */
    0xD3, 0x00,        /* display offset */
    0x40,              /* start line 0 */
    0x8D, 0x14,        /* charge pump on */
    0x20, 0x00,        /* horizontal addressing */
    0xA1, 0xC8,        /* segment remap, COM scan descending */
    0xDA, 0x02,        /* COM pins for 128x32 */
    0x81, contrast,
    0xD9, 0xF1,        /* pre-charge */
    0xDB, 0x40,        /* VCOMH */
    0x2E,              /* no scrolling */
    0xA4, 0xA6,        /* follow RAM, normal (not inverted) */
  };
  if (!w(SSW_OLED_CTRL_CMD, seq, (uint16_t)sizeof(seq))) return false;
  uint8_t blank[SSW_OLED_W];
  memset(blank, 0, sizeof(blank));
  for (unsigned p = 0; p < SSW_OLED_PAGES; p++) {
    const uint8_t win[] = { 0x21, 0x00, 0x7F, 0x22, (uint8_t)p, (uint8_t)p };
    if (!w(SSW_OLED_CTRL_CMD, win, (uint16_t)sizeof(win)) || !w(SSW_OLED_CTRL_DATA, blank, SSW_OLED_W)) return false;
  }
  return SswOled_Power(w, true);
}

bool SswOled_Contrast(SswOledWrite w, uint8_t contrast)
{
  const uint8_t c[] = { 0x81, contrast };
  return w(SSW_OLED_CTRL_CMD, c, 2U);
}

bool SswOled_Power(SswOledWrite w, bool on)
{
  const uint8_t c = on ? 0xAF : 0xAE;
  return w(SSW_OLED_CTRL_CMD, &c, 1U);
}

bool SswOled_Flush(SswOledWrite w, const uint8_t *fb, unsigned first, unsigned last)
{
  if (last >= SSW_OLED_PAGES) last = SSW_OLED_PAGES - 1U;
  for (unsigned p = first; p <= last; p++) {
    const uint8_t win[] = { 0x21, 0x00, 0x7F, 0x22, (uint8_t)p, (uint8_t)p };
    if (!w(SSW_OLED_CTRL_CMD, win, (uint16_t)sizeof(win))) return false;
    if (!w(SSW_OLED_CTRL_DATA, &fb[p * SSW_OLED_W], SSW_OLED_W)) return false;
  }
  return true;
}

/* ---- drawing -------------------------------------------------------------- */
void SswOled_Clear(uint8_t *fb) { memset(fb, 0, SSW_OLED_FB_SIZE); }

void SswOled_ClearLine(uint8_t *fb, unsigned line)
{
  if (line < SSW_OLED_PAGES) memset(&fb[line * SSW_OLED_W], 0, SSW_OLED_W);
}

unsigned SswOled_Text(uint8_t *fb, unsigned x, unsigned line, const char *s, bool invert)
{
  if (line >= SSW_OLED_PAGES || s == 0) return x;
  uint8_t *row = &fb[line * SSW_OLED_W];
  if (invert && x > 0U && x < SSW_OLED_W) row[x - 1U] = 0xFF;      /* left margin */
  for (; *s && x < SSW_OLED_W; s++) {
    const uint8_t *g = glyph(*s);
    for (unsigned c = 0; c < 6U && x < SSW_OLED_W; c++, x++) {
      uint8_t col = c < 5U ? g[c] : 0x00;
      row[x] = invert ? (uint8_t)~col : col;
    }
  }
  return x;
}

unsigned SswOled_TextBig(uint8_t *fb, unsigned x, unsigned line, const char *s)
{
  if (line + 1U >= SSW_OLED_PAGES || s == 0) return x;
  uint8_t *top = &fb[line * SSW_OLED_W], *bot = &fb[(line + 1U) * SSW_OLED_W];
  for (; *s && x + 1U < SSW_OLED_W; s++) {
    const uint8_t *g = glyph(*s);
    for (unsigned c = 0; c < 6U && x + 1U < SSW_OLED_W; c++, x += 2U) {
      uint8_t col = c < 5U ? g[c] : 0x00;
      uint16_t tall = 0;                                  /* each bit doubled vertically */
      for (unsigned b = 0; b < 8U; b++) if (col & (1U << b)) tall |= (uint16_t)(3U << (2U * b));
      top[x] = top[x + 1U] = (uint8_t)tall;
      bot[x] = bot[x + 1U] = (uint8_t)(tall >> 8);
    }
  }
  return x;
}

void SswOled_Bar(uint8_t *fb, unsigned x, unsigned line, unsigned w, unsigned permille)
{
  if (line >= SSW_OLED_PAGES || w < 3U) return;
  if (x + w > SSW_OLED_W) w = SSW_OLED_W - x;
  if (permille > 1000U) permille = 1000U;
  uint8_t *row = &fb[line * SSW_OLED_W];
  unsigned fill = 1U + ((w - 2U) * permille) / 1000U;
  for (unsigned i = 0; i < w; i++) {
    if (i == 0U || i == w - 1U) row[x + i] = 0x7E;             /* sides, rows 1..6 */
    else row[x + i] = (uint8_t)(i < fill ? 0x7E : 0x42);       /* filled, or top + bottom */
  }
}
